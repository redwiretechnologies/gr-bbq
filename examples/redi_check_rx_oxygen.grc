options:
  parameters:
    author: jbonior
    generate_options: qt_gui
    id: redi_check_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 433.94e6
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: bbq_manchester_1
  id: bbq_manchester
  parameters:
    coding_scheme: '1'
    preamble: '[1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, 1, -1, -1, 1, 1, -1, -1, 1, 1, -1]'
    sps: '5'
    verbose: 'False'
  states: {}
- name: bbq_packet_parser_0
  id: bbq_packet_parser
  parameters: {}
  states: {}
- name: bbq_packet_to_zmq_0
  id: bbq_packet_to_zmq
  parameters:
    address: tcp://*:4001
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.15'
    init: '0'
    low: '0.05'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '16384'
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: rwt_source_0
  id: rwt_source
  parameters:
    auto_filter: 'True'
    bandwidth: int(samp_rate)
    base_addr: '0x9D000000'
    bbdc: 'True'
    buffer_size: '32000'
    bypass_enable: 'False'
    correction_enable: 'True'
    escape: '0xAAAAAAAAAAAAAAAA'
    extra: ''
    filter: ''
    force_reload: 'False'
    freq: center_freq
    gain_mode: manual
    manual_gain: '50.0'
    quadrature: 'True'
    rfdc: 'True'
    rfport1: A_BALANCED
    rfport2: A_BALANCED
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: int(samp_rate)
    use_tags: 'True'
  states: {}
- name: rwt_tools_ook_preamble_correlator_0
  id: rwt_tools_ook_preamble_correlator
  parameters:
    preamble: preamble
    sampleRate: '2000000'
    symbolRate: '4000'
    threshold: len(preamble)*500*0.5
  states: {}
- name: rwt_tools_stream_to_message_0
  id: rwt_tools_stream_to_message
  parameters:
    fixed_size: '0'
    max_packet_buffer: '10000'
    message_size: '1024'
    min_packet_buffer: '10000'
    type: '2'
  states: {}

connections:
- [bbq_manchester_1, data_out, bbq_packet_parser_0, bits_in]
- [bbq_packet_parser_0, data_out, bbq_packet_to_zmq_0, packet_in]
- [bbq_packet_parser_0, data_out, blocks_message_debug_0, print]
- [blocks_add_const_vxx_0, '0', rwt_tools_ook_preamble_correlator_0, '0']
- [blocks_complex_to_mag_0_0_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_keep_one_in_n_0, '0', rwt_tools_stream_to_message_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [rwt_source_0, '0', blocks_complex_to_mag_0_0_0, '0']
- [rwt_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rwt_tools_ook_preamble_correlator_0, '0', blocks_keep_one_in_n_0, '0']
- [rwt_tools_ook_preamble_correlator_0, '1', blocks_null_sink_0, '0']
- [rwt_tools_stream_to_message_0, message_out, bbq_manchester_1, symbols_in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-802-g61ba4c66
